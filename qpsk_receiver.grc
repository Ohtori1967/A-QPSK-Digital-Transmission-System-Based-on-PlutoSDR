options:
  parameters:
    author: Ohtori1967
    category: Custom
    generate_options: qt_gui
    id: mpsk_stage6
    output_language: python
    title: QPSK Receiver
  states: {}

blocks:
- name: arity
  id: variable
  parameters:
    value: '4'
  states: {}
- name: delay
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Delay
    start: '0'
    step: '1'
    stop: '200'
    value: '50'
  states: {}
- name: eq_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@1: 0,1,1,1'
    label: 'Equalizer: rate'
    start: '0.0'
    step: '0.001'
    stop: '0.1'
    value: '0.01'
    widget: slider
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: filepath
  id: variable
  parameters:
    value: '"C:/Users/Ohtori1967/Desktop/qpsk_tx_rx_system/rx"'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 0,1,1,1'
    label: Frequency Offset
    start: '-0.1'
    step: '0.001'
    stop: '0.1'
    value: '0'
  states: {}
- name: header_format_default
  id: variable_header_format_default
  parameters:
    access_code: '11111111000000001111111100000000'
    bps: '1'
    threshold: '0'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise_volt
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 0,0,1,1'
    label: Noise Voltage
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.0001'
  states: {}
- name: phase_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@1: 0,2,1,1'
    label: 'Phase: Bandwidth'
    start: '0.0'
    step: '0.01'
    stop: '1.0'
    value: 6.28/100.0
    widget: slider
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1500000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: taps
  id: variable
  parameters:
    value: '[1.0, 0.25-0.25j, 0.50 + 0.10j, -0.3 + 0.2j]'
  states: {}
- name: time_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 0,2,1,1'
    label: Timing Offset
    start: '0.999'
    step: '0.0001'
    stop: '1.001'
    value: '1.00'
  states: {}
- name: timing_loop_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@1: 0,0,1,1'
    label: 'Time: BW'
    start: '0.0'
    step: '0.01'
    stop: '0.2'
    value: 6.28/100.0
    widget: slider
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: qpsk
    modulus: '4'
    step_size: '.0001'
    type: cma
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: int(delay)
    type: float
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"frame"'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"frame"'
    packet_len: '512'
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (0xdb, 0x30, 0xf7, 0x03,)
  states: {}
- name: controls
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,1,2
    label0: Channel
    label1: Receiver
    num_tabs: '2'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '11011011001100001111011100000011'
    tagname: frame
    threshold: '0'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: arity
    w: phase_bw
  states: {}
- name: digital_crc32_bb_0_0
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: frame
    packed: 'True'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '15'
    sps: '2'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,1,2,3]'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: timing_loop_bw
    max_dev: '1.5'
    osps: '2'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import os
      import struct
      import numpy as np
      from gnuradio import gr

      class blk(gr.basic_block):
          """
          File Reassembler (scan-stream, single-shot):
          - Scan byte stream for magic b'FILE'
          - Parse meta_len / name_len / file_size / name
          - Then write exactly file_size bytes after the meta
          - Write to .part and rename on completion
          - After done: drop all bytes (safe to stop anytime)
          """

          def __init__(self, out_dir="C:/tmp/out", debug=True, overwrite=True, max_buffer=4*1024*1024):
              gr.basic_block.__init__(self, name="File Reassembler (scan-stream)", in_sig=[np.uint8], out_sig=None)
              self.out_dir = out_dir
              self.debug = bool(debug)
              self.overwrite = bool(overwrite)
              self.max_buffer = int(max_buffer)

              os.makedirs(self.out_dir, exist_ok=True)

              self.state = "SCAN"
              self.buf = bytearray()

              self.meta_len = None
              self.file_size = None
              self.file_name = None

              self.fh = None
              self.part_path = None
              self.final_path = None
              self.written = 0
              self.done = False

          def _log(self, s):
              if self.debug:
                  print("[REASM]", s)

          def _close(self):
              try:
                  if self.fh:
                      self.fh.flush()
                      self.fh.close()
              except Exception:
                  pass
              self.fh = None

          def _open_out(self, name, size):
              safe = os.path.basename(name) if name else "recv.bin"
              final = os.path.join(self.out_dir, safe)
              part  = final + ".part"

              if (not self.overwrite) and os.path.exists(final):
                  base, ext = os.path.splitext(final)
                  k = 1
                  while os.path.exists(f"{base}_{k}{ext}") or os.path.exists(f"{base}_{k}{ext}.part"):
                      k += 1
                  final = f"{base}_{k}{ext}"
                  part  = final + ".part"

              self.final_path = final
              self.part_path  = part

              self._close()
              self.fh = open(self.part_path, "wb")
              self.written = 0
              self._log(f"OPEN {self.part_path} (expect {size} bytes)")

          def _finish(self):
              self._close()
              try:
                  if os.path.exists(self.final_path):
                      os.remove(self.final_path)
              except Exception:
                  pass
              os.replace(self.part_path, self.final_path)
              self._log(f"DONE {self.final_path} (written={self.written})")

          def _try_parse_meta_at(self, idx):
              # need at least fixed 16 bytes header
              if len(self.buf) < idx + 16:
                  return False

              if self.buf[idx:idx+4] != b"FILE":
                  return False

              ver = self.buf[idx+4]
              meta_len = struct.unpack("<H", self.buf[idx+5:idx+7])[0]
              name_len = self.buf[idx+7]
              fsize = struct.unpack("<Q", self.buf[idx+8:idx+16])[0]

              # sanity checks to reduce false positive
              if ver != 1:
                  return False
              if meta_len < 16 or meta_len > 4096:
                  return False
              if name_len > 255:
                  return False
              if fsize <= 0 or fsize > (1024**3):  # 1GB cap
                  return False

              if len(self.buf) < idx + meta_len:
                  return False  # wait more bytes

              name_end = idx + 16 + name_len
              if name_end > idx + meta_len:
                  return False

              name = bytes(self.buf[idx+16:name_end]).decode("utf-8", errors="ignore").strip("\x00")
              if not name:
                  name = "recv.bin"

              self.meta_len = meta_len
              self.file_size = fsize
              self.file_name = name

              self._log(f"META ok @ {idx}: ver={ver}, meta_len={meta_len}, name={name}, size={fsize}")
              return True

          def general_work(self, input_items, output_items):
              inp = input_items[0]
              n = len(inp)

              if self.done:
                  self.consume(0, n)
                  return 0

              # append to buffer
              self.buf += bytes(inp)

              # prevent runaway memory if no sync
              if len(self.buf) > self.max_buffer:
                  # keep last 1MB
                  self.buf = self.buf[-1024*1024:]

              if self.state == "SCAN":
                  # search for 'FILE'
                  # we search all occurrences, pick the first that passes sanity + full meta present
                  start = 0
                  while True:
                      idx = self.buf.find(b"FILE", start)
                      if idx < 0:
                          break
                      if self._try_parse_meta_at(idx):
                          # consume bytes before meta start
                          if idx > 0:
                              del self.buf[:idx]
                          # now buf starts with FILE...
                          # consume full meta
                          del self.buf[:self.meta_len]
                          self._open_out(self.file_name, self.file_size)
                          self.state = "RECV"
                          break
                      start = idx + 1

              if self.state == "RECV" and self.fh is not None:
                  remain = self.file_size - self.written
                  if remain > 0 and len(self.buf) > 0:
                      take = min(remain, len(self.buf))
                      chunk = self.buf[:take]
                      self.fh.write(chunk)
                      self.written += take
                      del self.buf[:take]

                  if self.written >= self.file_size:
                      self._finish()
                      self.done = True
                      self.state = "DONE"

              self.consume(0, n)
              return 0

          def stop(self):
              self._close()
              return True
    debug: 'True'
    max_buffer: '1024'
    out_dir: filepath
    overwrite: 'True'
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: '3800000000'
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate*2
    type: fc32
    uri: 192.168.4.1
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      The CMA equalizer has been
      replaced by a Linear Equalizer
      and an Adaptive Algorithm for
      version 3.9
    note: CMA equalizer replaced
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 'received@0: 0,0,1,1'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 'received@1: 0,0,1,1'
    label1: Symbols
    name: ''
    size: '500'
    srate: samp_rate
    type: float
    ymax: '4'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 2,1,1,1
    label1: Rx Bits
    label2: Tx Bits
    name: ''
    nconnections: '2'
    size: '128'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ymax: '2'
  states: {}
- name: received
  id: qtgui_tab_widget
  parameters:
    gui_hint: 2,0,1,1
    label0: Constellation
    label1: Symbols
    num_tabs: '2'
  states: {}

connections:
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_char_to_float_0_0_0, '0', blocks_delay_0, '0']
- [blocks_delay_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_repack_bits_bb_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_crc32_bb_0_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_char_to_float_0_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', blocks_char_to_float_0_0_0, '0']
- [blocks_vector_source_x_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_char_to_float_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_crc32_bb_0_0, '0', epy_block_0, '0']
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_linear_equalizer_0, '0', digital_costas_loop_cc_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_linear_equalizer_0, '0']
- [iio_pluto_source_0, '0', digital_pfb_clock_sync_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
